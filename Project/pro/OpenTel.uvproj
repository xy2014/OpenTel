# Keil uVision project OpenTel.uvproj, settings and files
target OpenTel (ARM-ADS)
  device: STM32F102RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: OpenTel +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\pro;..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\User\inc;..\..\Utilities;..\..\USMART;..\..\Bb242x_Lib_Tx\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ./: system_stm32f10x.c
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group STM32_LIB
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_i2c.c stm32f10x_sdio.c
  group USER
    ./: main.c stm32f10x_it.c
    ../../User/src/: led.c adc.c spi.c encode.c mlib.c uart.c eeprom.c button.c stickKnob.c beep.c timer.c
  group Utilities
    ../../Utilities/: stm3210e_eval.c
  group USMART
    ../../USMART/: usmart.c usmart_config.c usmart_str.c
  group Bk242x_Lib_Tx
    ../../Bb242x_Lib_Tx/src/: bk242x.c bk242x_sub.c rfPackage.c
